* C:\Users\YUVARAJ.N\eSim-Workspace\esimfun\esimfun.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/08/22 23:16:49

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
SC6  Net-_SC6-Pad1_ Net-_SC18-Pad1_ Net-_SC17-Pad2_ sky130_stdcells__or2_0
SC7  Net-_SC31-Pad2_ Net-_SC23-Pad2_ Net-_SC7-Pad3_ sky130_stdcells__or2_0
SC31  Net-_SC23-Pad2_ Net-_SC31-Pad2_ ? sky130_stdcells__and2_0
SC30  Net-_SC30-Pad1_ Net-_SC30-Pad2_ Net-_SC13-Pad2_ sky130_stdcells__and2_0
SC24  Net-_SC24-Pad1_ Net-_SC24-Pad1_ Net-_SC24-Pad1_ Net-_SC24-Pad1_ Net-_SC21-Pad2_ sky130_stdcells__and4_1
SC25  Net-_SC25-Pad1_ Net-_SC25-Pad1_ Net-_SC25-Pad1_ Net-_SC25-Pad1_ Net-_SC24-Pad1_ sky130_stdcells__and4_1
SC17  Net-_SC17-Pad1_ Net-_SC17-Pad2_ Net-_SC17-Pad3_ sky130_stdcells__or2_0
U2  Net-_U1-Pad4_ Net-_SC32-Pad3_ ? Net-_U2-Pad4_ Net-_U2-Pad4_ count23
U3  Net-_U2-Pad4_ Net-_SC32-Pad3_ Net-_U14-Pad~_ Net-_U3-Pad4_ Net-_U3-Pad4_ count23
U1  Net-_SC26-Pad3_ Net-_SC32-Pad3_ ? Net-_U1-Pad4_ Net-_U1-Pad4_ count23
SC2  Net-_SC2-Pad1_ Net-_SC1-Pad1_ sky130_tests__not
SC9  Net-_SC15-Pad2_ Net-_SC2-Pad1_ sky130_tests__not
SC15  Net-_SC15-Pad1_ Net-_SC15-Pad2_ sky130_tests__not
SC19  Net-_SC10-Pad2_ Net-_SC15-Pad1_ sky130_tests__not
SC1  Net-_SC1-Pad1_ Net-_SC1-Pad2_ sky130_tests__not
SC10  Net-_SC1-Pad2_ Net-_SC10-Pad2_ sky130_tests__not
SC26  Net-_SC10-Pad2_ Net-_SC18-Pad2_ Net-_SC26-Pad3_ sky130_stdcells__and2_0
scmode1  SKY130mode
SC32  Net-_SC18-Pad2_ Net-_SC28-Pad2_ Net-_SC32-Pad3_ sky130_stdcells__and2_0
U4  Net-_SC7-Pad3_ Net-_SC25-Pad1_ Net-_U18-Pad2_ xor21
U5  Net-_SC23-Pad1_ Net-_SC6-Pad1_ Net-_U17-Pad2_ xor21
U9  Net-_SC23-Pad2_ plot_v1
U8  Net-_SC18-Pad2_ plot_v1
U7  Net-_SC28-Pad2_ plot_v1
U10  Net-_SC6-Pad1_ plot_v1
U11  Net-_SC13-Pad1_ plot_v1
U12  Net-_SC14-Pad1_ plot_v1
U13  Net-_SC14-Pad2_ plot_v1
U14  Net-_U14-Pad~_ plot_v1
SC12  Net-_SC11-Pad1_ /C1 GND GND sky130_fd_pr__nfet_01v8
SC4  /C1 Net-_SC11-Pad1_ GND GND sky130_fd_pr__nfet_01v8
SC11  Net-_SC11-Pad1_ /C1 Net-_SC11-Pad3_ Net-_SC11-Pad3_ sky130_fd_pr__pfet_01v8
SC3  /C1 ? Net-_SC11-Pad3_ Net-_SC11-Pad3_ sky130_fd_pr__pfet_01v8
v1  Net-_SC11-Pad3_ GND DC
U6  Net-_SC18-Pad2_ Net-_SC23-Pad2_ Net-_U16-Pad3_ Net-_SC30-Pad2_ dlatch31
U16  Net-_SC18-Pad2_ Net-_SC30-Pad2_ Net-_U16-Pad3_ Net-_SC30-Pad1_ dlatch31
U17  Net-_SC18-Pad2_ Net-_U17-Pad2_ Net-_SC17-Pad3_ Net-_SC31-Pad2_ dlatch31
U18  Net-_SC18-Pad2_ Net-_U18-Pad2_ Net-_U16-Pad3_ Net-_SC25-Pad1_ dlatch31
U19  Net-_SC11-Pad1_ Net-_SC18-Pad2_ inv11
SC13  Net-_SC13-Pad1_ Net-_SC13-Pad2_ Net-_SC13-Pad3_ Net-_SC13-Pad3_ sky130_fd_pr__nfet_01v8
SC8  Net-_SC13-Pad1_ Net-_SC13-Pad2_ Net-_SC8-Pad3_ Net-_SC8-Pad3_ sky130_fd_pr__pfet_01v8
SC16  Net-_SC14-Pad1_ Net-_SC14-Pad2_ GND GND sky130_fd_pr__nfet_01v8
SC22  Net-_SC14-Pad2_ Net-_SC21-Pad2_ GND GND sky130_fd_pr__nfet_01v8
SC29  ? Net-_SC28-Pad2_ GND GND sky130_fd_pr__nfet_01v8
SC14  Net-_SC14-Pad1_ Net-_SC14-Pad2_ Net-_SC14-Pad3_ Net-_SC14-Pad3_ sky130_fd_pr__pfet_01v8
SC21  Net-_SC14-Pad2_ Net-_SC21-Pad2_ Net-_SC14-Pad3_ Net-_SC14-Pad3_ sky130_fd_pr__pfet_01v8
SC28  Net-_SC17-Pad1_ Net-_SC28-Pad2_ Net-_SC14-Pad3_ Net-_SC14-Pad3_ sky130_fd_pr__pfet_01v8
SC20  Net-_SC18-Pad1_ Net-_SC18-Pad2_ GND GND sky130_fd_pr__nfet_01v8
SC18  Net-_SC18-Pad1_ Net-_SC18-Pad2_ Net-_SC14-Pad3_ Net-_SC14-Pad3_ sky130_fd_pr__pfet_01v8
SC27  Net-_SC23-Pad1_ Net-_SC23-Pad2_ GND GND sky130_fd_pr__nfet_01v8
SC23  Net-_SC23-Pad1_ Net-_SC23-Pad2_ Net-_SC14-Pad3_ Net-_SC14-Pad3_ sky130_fd_pr__pfet_01v8
v2  Net-_SC14-Pad3_ GND DC

.end
